<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\BU01_STATION.ewp</path>
  </project>
  <batchBuild />
</workspace>
